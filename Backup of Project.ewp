# IAR project Backup of Project.ewp, settings and files
configuration STM8S105 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8S103 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: STM8S103
configuration STM8S003F3 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  ICCSTM8.CCDefines: STM8S103
  OBJCOPY.OOCOutputFile: Program_SE001_SST141-1.hex
  group StdPeriph_Drivers
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
  group User
    ../: function.c main.c stm8s_it.c
